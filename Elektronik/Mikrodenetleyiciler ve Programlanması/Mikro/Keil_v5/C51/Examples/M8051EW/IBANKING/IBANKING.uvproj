# Keil uVision project IBANKING.uvproj, settings and files
target LX51 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: IBANKING +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: IBANKING
  group Source Files
    ./: C_root.c C_bank0.c C_bank1.c C_bank2.c
  group Documentation
    ./: Abstract.txt
target BL51 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: IBANKING +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: IBANKING
